* opamp
*
** Circuit Description **
*
* front-end stage
M2 200 8 201 201 CMOSN L={l2} W={w2}
M3 6 2 7 5 CMOSN L={l3} W={w3}
M4 3 1 7 5 CMOSN L={l4} W={w4}
M5 6 6 4 4 CMOSP L={l5} W={w5}
M6 3 6 4 4 CMOSP L={l6} W={w6}
* current source biasing stage
M1 8 8 5 5 CMOSN L={l1} W={w1}
Iref 4 8 dc {Iref}
* load for the op-amp
CL 3 0 {CL}
