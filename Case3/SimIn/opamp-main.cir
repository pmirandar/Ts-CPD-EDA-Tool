* opamp desciption
* power supplies
VDD 4 0 DC +2.5V
Vss 5 0 DC -2.5V
*Vc1 2 0 DC 1.2V
*Vc2 5 0 DC 1.2V
* differential-mode signal level
*Vd 21 0 DC 0V
Vd 101 0 sin(0 0.1 100000000) ac 1.0V dc 0.0
*Vd 21 0 dc 0.0 ac 1 0
*+ distof1 1 0
*+ distof2 1 0
*+ sin(0 0.1V 100000000 0 0)
*vin 2 5 sin(0 0.1 20000000) ac 1.0V dc 0.0
* to DC sweep the input common-mode level, offset diff-input by +220uV
*Vd 21 0 DC +220.0uV
Rd 101 0 1
EV1 2 100 101 0 +0.5
EV2 1 100 101 0 -0.5
*EV1 2 100 101 0 +1.0
*EV2 1 100 101 0 -1.0
* common-mode signal level
Vcm 100 0 DC 0V
* front-end stage
M2 7 8 5 5 CMOSN L={l2} W={w2}
M3 6 1 7 5 CMOSN L={l3} W={w3}
M4 10 2 7 5 CMOSN L={l4} W={w4}
M5 6 6 4 4 CMOSP L={l5} W={w5}
M6 10 6 4 4 CMOSP L={l6} W={w6}
* 2nd gain stage
M7 3 10 4 4 CMOSP L={l7} W={w7}
M8 3 8 5 5 CMOSN L={l8} W={w8}
* current source biasing stage
M1 8 8 5 5 CMOSN L={l1} W={w1}
Iref 4 8 dc {Iref}
* compensation network
Cc 10 3 {CAPc}
* load for the op-amp
CL 3 0 {CL}
